# Keil uVision project Nucleo-F091RC.uvprojx, settings and files
target Nucleo-bord (6180000::V6.18::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Nucleo-F091RC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./: ad.c buttons.c leds.c main.c usart2.c apa102c.c spi1.c mpr121.c i2c1.c pwm.c timer6.c
  group Headers
    ./: ad.h buttons.h leds.h usart2.h apa102c.h spi1.h mpr121.h i2c1.h pwm.h timer6.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
